# Keil uVision project Lpc2148_I2C_SPI_.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Lpc2148_I2C_SPI_ +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s lpc2148_i2c.c tc74_main.c Uart0.c i2c_test.c 25lc256_spi_main.c spi_test.c lpc_test.c
