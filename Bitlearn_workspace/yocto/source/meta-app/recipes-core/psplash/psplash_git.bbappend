
#by copying splash screen logo in files and the file path is appended that recipe pics it and applies
#png name should be psplash-poky-img.png 

FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
